# Keil uVision project LSM9DS1.uvproj, settings and files
target LSM9DS1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LSM9DS1 +hex
  c flags: Optim=1
  c include: ..\lib\CMSIS\CM3\CoreSupport;..\lib\STM32F10x_StdPeriph_Driver\inc;..\srccode
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group lib
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group srccode
    ../srccode/: main.c Retarget.c stm32f10x_it.c device.c unoptimize.c system_stm32f10x.c startup_stm32f10x_hd.s lsm9ds1.c myiic.c delay.c
